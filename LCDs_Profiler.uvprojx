# Keil uVision project LCDs_Profiler.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LCDs_Profiler
  AfterMake: Scripts\update_regions_MDK.bat !L
  AfterMake: Scripts\find_sizes.bat !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --fpmode=fast
  c include: .\Include;.\Source\Profiler;.\Source\LCD;.\Source\FS;.\Source\ulibSD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  link misc: --info inline --info visibility
  group Application
    ./Source/: delay.c LEDs.c main.c MMA8451.c debug.c I2C.c timers.c UART.c queue.c
    ./Include/: debug.h delay.h GPIO_defs.h I2C.h LEDs.h misc.h MMA8451.h picojpeg.h queue.h timers.h UART.h
  group Profiler
    ./Source/Profiler/: profile.c region.c PIT.c PIT.h profile.h region.h
  group LCD
    ./Source/LCD/: LCD_JPEG.c LCD_graphics.c LCD_text.c lucida_8x13.c lucida_12x19.c ST7789.c touchscreen.c picojpeg.c colors.c
  group FS
    ./Source/FS/: diskio.c pff.c diskio.h pff.h pffconf.h
  group ulibSD
    ./Source/ulibSD/: sd_io.c sd_io.h spi_io.c spi_io.h
software components: CMSIS:CORE 5.0.2, Device:Startup 2.5.0
